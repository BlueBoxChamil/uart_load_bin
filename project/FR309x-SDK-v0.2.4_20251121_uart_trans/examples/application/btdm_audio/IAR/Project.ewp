# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Project.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pe177,Pe550,Pa082,Ta023,Ta022
  ICCARM.CCIncludePath2: ..\..\..\..\components\btdm\include; ..\..\..\..\components\drivers\cmsis; ..\..\..\..\components\drivers\device; ..\..\..\..\components\drivers\device\fr30xx; ..\..\..\..\components\drivers\peripheral\Inc; ..\..\..\..\components\modules\common\include; ..\..\..\..\components\modules\crc; ..\..\..\..\components\modules\FlashDB\flashdb\inc; ..\..\..\..\components\modules\FlashDB\port\fal\inc; ..\..\..\..\components\modules\FreeRTOS\include; ..\..\..\..\components\modules\FreeRTOS\portable\ARMv8M\non_secure; ..\..\..\..\components\modules\FreeRTOS\portable\ARMv8M\non_secure\portable\IAR\ARM_CM33_NTZ; ..\..\..\..\components\modules\heap; ..\..\..\..\examples\common\btdm; ..\..\..\..\examples\common\flashdb; ..\Inc; ..\Src; ..\..\..\..\components\modules\audio; ..\..\..\..\components\modules\audio\algorithm; ..\..\..\..\components\modules\audio\codec; ..\..\..\..\components\modules\audio\resample; ..\..\..\..\components\modules\dsp; ..\..\..\..\components\modules\fatfs\source; ..\..\..\..\components\modules\FlashDB\flashdb\inc; ..\..\..\..\components\modules\FlashDB\port\fal\inc; ..\..\..\..\components\modules\rpmsg-lite\lib\include; ..\..\..\..\components\modules\rpmsg-lite\lib\include\platform\fr30xx_m33; ..\..\..\common\btdm\profile\ble_ANCS_AMCS; ..\..\..\common\btdm\profile\ble_hid; ..\..\..\common\btdm\profile\ble_simple_gatt
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.sim
  postbuild: ..\..\..\..\..\components\tools\iar\post_process.bat $PROJ_FNAME$ "$TARGET_DIR$" "$EW_DIR$"
  ILINK.IlinkIcfFile: D:\My Document\FR5090_SDK\components\tools\iar\ldscript_3092e.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../Src/: app_at.c app_audio.c app_ble.c app_bt.c app_btdm.c app_hid_sdp.c app_rpmsg.c app_task.c diskio.c main.c mp3_sample.c sbc_sample.c user_bt.c
  group ble/profiles
    ../../../common/btdm/profile/ble_ANCS_AMCS/: AMS_client.c ANCS_AMS_client.c
    ../../../common/btdm/profile/ble_hid/: hid_service.c
    ../../../common/btdm/profile/ble_simple_gatt/: simple_gatt_service.c
  group common/btdm
    ../../../common/btdm/: btdm_mem.c controller.c controller_code_revb.c controller_code_revc.c host.c SWD.c
  group common/dsp
    ../../../common/dsp/: dsp_code_flash.c dsp_code_rom.c
  group common/flashdb
    ../../../common/flashdb/: fal_flash_port.c fdb_app.c
  group driver/device
    ../../../../components/drivers/device/fr30xx/: fr30xx.h system_fr30xx.c system_fr30xx.h trim_fr30xx.c
    ../../../../components/drivers/device/fr30xx/iar/: startup_fr30xx.s
  group driver/peripheral
    ../../../../components/drivers/peripheral/Src/: driver_cali.c driver_codec.c driver_efuse.c driver_flash.c driver_frspim.c driver_gpio.c driver_i2s.c driver_ipc.c driver_pdm.c driver_pmu.c driver_pmu_iwdt.c driver_qspi.c driver_sd.c driver_sd_card.c driver_spdif.c driver_trng.c driver_uart.c
  group module/audio
    ../../../../components/modules/audio/algorithm/: algorithm.c
    ../../../../components/modules/audio/: audio_a2dp_sink.c audio_a2dp_source.c audio_decoder.c audio_encoder.c audio_hw.c audio_rpmsg.c audio_scene.c audio_sco.c local_playback.c voice_recognize.c
    ../../../../components/modules/audio/codec/: codec.c
    ../../../../components/modules/audio/resample/: resample.c
  group module/btdm
    ../../../../components/btdm/: btdm_host.a
  group module/common
    ../../../../components/modules/common/src/: co_list.c co_log.c co_util.c
    ../../../../components/modules/crc/: crc32.c
  group module/dsp
    ../../../../components/modules/dsp/: dsp.c dsp_mem.c
  group module/fatfs
    ../../../../components/modules/fatfs/source/: ff.c ffsystem.c ffunicode.c
  group module/flashdb
    ../../../../components/modules/FlashDB/port/fal/src/: fal.c fal_flash.c fal_partition.c
    ../../../../components/modules/FlashDB/flashdb/src/: fdb.c fdb_kvdb.c fdb_utils.c
  group module/freertos
    ../../../../components/modules/FreeRTOS/: cpu_context_iar.s croutine.c event_groups.c freertos_sleep.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../components/modules/FreeRTOS/portable/MemMang/: heap_6.c
    ../../../../components/modules/FreeRTOS/portable/ARMv8M/non_secure/: port.c
    ../../../../components/modules/FreeRTOS/portable/ARMv8M/non_secure/portable/IAR/ARM_CM33_NTZ/: portasm.s
  group module/heap
    ../../../../components/modules/heap/: heap.c
  group module/rpmsg
    ../../../../components/modules/rpmsg-lite/lib/common/: llist.c
    ../../../../components/modules/rpmsg-lite/lib/rpmsg_lite/: rpmsg.c rpmsg_lite.c rpmsg_queue.c
    ../../../../components/modules/rpmsg-lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
    ../../../../components/modules/rpmsg-lite/lib/rpmsg_lite/porting/platform/fr30xx_cm33/: rpmsg_platform.c
    ../../../../components/modules/rpmsg-lite/lib/virtio/: virtqueue.c
