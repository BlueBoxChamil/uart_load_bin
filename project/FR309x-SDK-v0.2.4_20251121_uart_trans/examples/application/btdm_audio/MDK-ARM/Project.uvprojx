# Keil uVision project Project.uvprojx, settings and files
target Project (6160000::V6.16::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: Project
  AfterMake: "..\..\..\..\components\tools\keil\post_process.bat" "@L" "#L" "$J"
  c flags: Optim=3 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: LV_CONF_INCLUDE_SIMPLE,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ..\..\..\..\components\btdm\include;..\..\..\..\components\drivers\cmsis;..\..\..\..\components\drivers\device\fr30xx;..\..\..\..\components\drivers\peripheral\Inc;..\..\..\..\components\modules\audio;..\..\..\..\components\modules\audio\algorithm;..\..\..\..\components\modules\audio\codec;..\..\..\..\components\modules\audio\resample;..\..\..\..\components\modules\common\include;..\..\..\..\components\modules\dsp;..\..\..\..\components\modules\fatfs\source;..\..\..\..\components\modules\FlashDB\flashdb\inc;..\..\..\..\components\modules\FlashDB\port\fal\inc;..\..\..\..\components\modules\FreeRTOS\include;..\..\..\..\components\modules\FreeRTOS\portable\ARMv8M\non_secure;..\..\..\..\components\modules\FreeRTOS\portable\ARMv8M\non_secure\portable\GCC\ARM_CM33_NTZ;..\..\..\..\components\modules\heap;..\..\..\..\components\modules\rpmsg-lite\lib\include;..\..\..\..\components\modules\rpmsg-lite\lib\include\platform\fr30xx_m33;..\..\..\common\btdm;..\..\..\common\flashdb;..\Inc;..\Src;..\..\..\common\btdm\profile\ble_ANCS_AMCS;..\..\..\common\btdm\profile\ble_hid;..\..\..\common\btdm\profile\ble_simple_gatt;..\..\..\..\components\modules\crc;..\..\..\..\components\modules\ext_flash_program;..\..\..\common\lwip_port;..\..\..\common\lwip_port\arch
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT5: ROM 0x1ffc0000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ..\..\..\..\components\tools\keil\xip_flash_fr3092e.sct
  group CMSIS
    ../../../../components/drivers/cmsis/: core_cm33.h
  group app
    ../Src/: main.c app_audio.c app_ble.c app_bt.c app_btdm.c app_at.c app_rpmsg.c app_task.c diskio.c user_bt.c mp3_sample.c sbc_sample.c app_hid_sdp.c py_uart_trans.c
    ../Inc/: app_config.h
  group ble/profile
    ../../../common/btdm/profile/ble_ANCS_AMCS/: ANCS_AMS_client.c AMS_client.c
    ../../../common/btdm/profile/ble_simple_gatt/: simple_gatt_service.c
    ../../../common/btdm/profile/ble_hid/: hid_service.c
  group common/btdm
    ../../../common/btdm/: btdm_mem.c controller.c host.c SWD.c controller_code.s
  group common/dsp
    ../../../common/dsp/: dsp_code_flash.s dsp_code_rom.s
  group common/flashdb
    ../../../common/flashdb/: fal_flash_port.c fdb_app.c
  group driver/device
    ../../../../components/drivers/device/fr30xx/: fr30xx.h system_fr30xx.h system_fr30xx.c trim_fr30xx.c
    ../../../../components/drivers/device/fr30xx/armcc/: startup_fr30xx.s
  group driver/peripheral
    ../../../../components/drivers/peripheral/Src/: driver_cali.c driver_codec.c driver_efuse.c driver_flash.c driver_frspim.c driver_gpio.c driver_i2s.c driver_ipc.c driver_pdm.c driver_pmu.c driver_pmu_iwdt.c driver_qspi.c driver_sd.c driver_sd_card.c driver_spdif.c driver_uart.c driver_trng.c
  group module/audio
    ../../../../components/modules/audio/algorithm/: algorithm.c
    ../../../../components/modules/audio/codec/: codec.c
    ../../../../components/modules/audio/resample/: resample.c
    ../../../../components/modules/audio/: audio_decoder.c audio_encoder.c audio_hw.c audio_rpmsg.c audio_scene.c audio_a2dp_sink.c audio_a2dp_source.c audio_sco.c local_playback.c
  group module/btdm
    ../../../../components/btdm/: btdm_host.lib
  group module/common
    ../../../../components/modules/common/src/: co_log.c co_list.c co_util.c
    ../../../../components/modules/ext_flash_program/: ext_flash_program.c
  group module/crc
    ../../../../components/modules/crc/: crc32.c
  group module/dsp
    ../../../../components/modules/dsp/: dsp.c dsp_mem.c
  group moudle/fatfs
    ../../../../components/modules/fatfs/source/: ff.c ffsystem.c ffunicode.c
  group module/flashdb
    ../../../../components/modules/FlashDB/port/fal/src/: fal.c fal_flash.c fal_partition.c
    ../../../../components/modules/FlashDB/flashdb/src/: fdb.c fdb_kvdb.c fdb_utils.c
  group module/freertos
    ../../../../components/modules/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c freertos_sleep.c cpu_context.s
    ../../../../components/modules/FreeRTOS/portable/ARMv8M/non_secure/: port.c
    ../../../../components/modules/FreeRTOS/portable/ARMv8M/non_secure/portable/GCC/ARM_CM33_NTZ/: portasm.c
    ../../../../components/modules/FreeRTOS/portable/MemMang/: heap_6.c
  group module/heap
    ../../../../components/modules/heap/: heap.c
  group module/rpmsg
    ../../../../components/modules/rpmsg-lite/lib/rpmsg_lite/: rpmsg.c rpmsg_lite.c rpmsg_queue.c
    ../../../../components/modules/rpmsg-lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
    ../../../../components/modules/rpmsg-lite/lib/rpmsg_lite/porting/platform/fr30xx_cm33/: rpmsg_platform.c
    ../../../../components/modules/rpmsg-lite/lib/common/: llist.c
    ../../../../components/modules/rpmsg-lite/lib/virtio/: virtqueue.c
software components: Compiler:I/O:STDERR 1.2.0
